# Keil uVision project 5th_Lab.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 5th_Lab +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 5th_Lab.c
